# Keil uVision project project.uvproj, settings and files
target Target 1 ()
  device: LPC2148 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: project +hex
  group Source Group 1
    ./: Startup.s project.c
